FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

CFLAGS_append = " -DSQLITE_ENABLE_UNLOCK_NOTIFY"
